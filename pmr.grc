options:
  parameters:
    generate_options: qt_gui
    id: spektrumanalyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: center
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '446006250'
    step: '12500'
    stop: '446193750'
    value: '446081250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    ctrlpanel: 'True'
    fc: center
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10000'
    interp: '48'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: center
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
