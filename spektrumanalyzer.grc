options:
  parameters:
    generate_options: qt_gui
    id: spektrumanalyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '80000000'
    step: '100000'
    stop: '110000000'
    value: '95000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    name: '"Frequency"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
