options:
  parameters:
    generate_options: qt_gui
    id: pmr_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '446006250'
    step: '12500'
    stop: '446193750'
    value: '446081250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/tobias/Documents/projects/bulme-ksn-gnuradio/sprachmemo.wav
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
